# IAR project uvc.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DATA_SECTION_IS_CACHEABLE=1; _DEBUG=1; DEBUG; CPU_MIMXRT1176DVMAA_cm7; USB_STACK_BM; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CSI_DRIVER_FRAG_MODE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../src; ../src/board; ../src/camera; ../src/usb; ../../../../../../../middleware/usb/device; ../../../../../../../middleware/usb/include; ../../../../../../../middleware/usb/phy; ../../../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../../../devices/MIMXRT1176/drivers; ../../../../../../../devices/MIMXRT1176; ../../../../../../../components/video; ../../../../../../../components/video/camera; ../../../../../../../components/video/camera/device; ../../../../../../../components/video/camera/device/ov5640; ../../../../../../../components/video/camera/device/sccb; ../../../../../../../components/video/camera/receiver; ../../../../../../../components/video/camera/receiver/csi; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../devices/MIMXRT1176/xip; ../../../../../xip; ../../../../../../../components/osa; ../../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: uvc.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DATA_SECTION_IS_CACHEABLE=1; DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1176DVMAA_cm7; USB_STACK_BM; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK; SDK_I2C_BASED_COMPONENT_USED=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CSI_DRIVER_FRAG_MODE=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
  group board
    ../src/board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/osa
    ../../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group component/video
    ../../../../../../../components/video/: fsl_video_common.c fsl_video_common.h
  group component/video/camera
    ../../../../../../../components/video/camera/: fsl_camera.h
    ../../../../../../../components/video/camera/device/: fsl_camera_device.h
    ../../../../../../../components/video/camera/receiver/: fsl_camera_receiver.h
    ../../../../../../../components/video/camera/receiver/csi/: fsl_csi_camera_adapter.c fsl_csi_camera_adapter.h
    ../../../../../../../components/video/camera/device/ov5640/: fsl_ov5640.c fsl_ov5640.h
    ../../../../../../../components/video/camera/device/sccb/: fsl_sccb.c fsl_sccb.h
  group device
    ../../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MIMXRT1176/drivers/: fsl_anatop_ai.c fsl_anatop_ai.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_csi.c fsl_csi.h fsl_dcdc.c fsl_dcdc.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_mipi_csi2rx.c fsl_mipi_csi2rx.h fsl_pmu.c fsl_pmu.h fsl_pxp.c fsl_pxp.h fsl_soc_mipi_csi2rx.c fsl_soc_mipi_csi2rx.h
    ../../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group source
    ../src/: main.c
  group source/camera
    ../src/camera/: camera_support.c camera_support.h
  group source/usb
    ../src/usb/: usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h video_camera.c video_camera.h
  group startup
    ../../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group usb/device/class
    ../src/usb/: usb_device_class.c usb_device_class.h
  group usb/device/class/video
    ../src/usb/: usb_device_video.c usb_device_video.h
  group usb/device/include
    ../../../../../../../middleware/usb/device/: usb_device.h
  group usb/device/source
    ../src/usb/: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/ehci
    ../../../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb/include
    ../../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/phy
    ../../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group utilities
    ../../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
  group xip
    ../../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
    ../../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
