# IAR project uvc_demo.ewp, settings and files
configuration sdram_txt (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6A NXP MIMXRT1052xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6A; SKIP_SYSCLK_INIT; SDRAM_MPU_INIT; USB_STACK_BM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../src/board; ../src/camera; ../src/usb; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../middleware/usb; ../../../../../middleware/usb/osa; ../../../../../middleware/usb/include; ../../../../../middleware/usb/device; ../../../../../middleware/usb/phy; ../../../../../devices/MIMXRT1052/drivers; ../../../../../devices/MIMXRT1052; ../../../../../devices/MIMXRT1052/utilities/io; ../../../../../devices/MIMXRT1052/utilities/str; ../../../../../devices/MIMXRT1052/utilities/log; ../../../../../devices/MIMXRT1052/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: uvc_demo.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram_txt.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6A; SKIP_SYSCLK_INIT; SDRAM_MPU_INIT; USB_STACK_BM; XIP_EXTERNAL_FLASH
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: uvc_demo.bin
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_csi.c fsl_csi.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h
  group middleware/usb/device
    ../../../../../middleware/usb/device/: usb_device.h usb_device_dci.c usb_device_dci.h usb_device_ehci.c usb_device_ehci.h
  group middleware/usb/include
    ../../../../../middleware/usb/include/: usb.h usb_ehci.h usb_misc.h usb_spec.h
  group middleware/usb/osa
    ../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.c usb_osa_bm.h
  group middleware/usb/phy
    ../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group src
    ../src/: main.c
  group src/board
    ../src/board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group src/camera
    ../src/camera/: camera_device.c camera_device.h fsl_camera.h fsl_camera_device.h fsl_camera_receiver.h fsl_csi_camera_adapter.c fsl_csi_camera_adapter.h fsl_mt9m114.c fsl_mt9m114.h fsl_video_common.h
  group src/usb
    ../src/usb/: usb_device_ch9.c usb_device_ch9.h usb_device_class.c usb_device_class.h usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h usb_device_video.c usb_device_video.h video_camera.c video_camera.h
  group startup
    ../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
    ../../../../../devices/MIMXRT1052/: system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MIMXRT1052/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
